# IAR project RTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\abdul\CLionProjects\RTOS-kernel\src\Kernel\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: C:\Users\abdul\CLionProjects\RTOS-kernel\src\port
  OBJCOPY.OOCOutputFile: RTOS.srec
  ILINK.IlinkOutputFile: RTOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group sRTOS/Kernel/inc
    src/Kernel/inc/: bsp.h mrtos_config.h os_buffers.h os_core.h os_scheduling.h os_semaphore.h os_threads.h
  group sRTOS/Kernel/src
    src/Kernel/src/: os_buffers.c os_core.c os_scheduling.c os_semaphore.c os_threads.c
  group sRTOS/Port
    src/port/: bsp.c mrtos.s
